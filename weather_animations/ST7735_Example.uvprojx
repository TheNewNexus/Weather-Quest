# Keil uVision project ST7735_Example.uvprojx, settings and files
target ST7735_Example (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Walk Man
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c WeatherAnimations.c WeatherIcons.c WeatherIcons.h SysTick.c SysTick.h Switch.c Switch.h
software components: CMSIS:CORE 5.6.0
